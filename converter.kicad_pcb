# Repository jaseg/bikelights

## KiCad design converter.kicad_pcb

Parts:
C1, C6: 100n
C2, C8: 100µ
C3, C5: 22p
C4, C12: 1µ
C7: 470µ
C9: 47µ
C10, C11: C
D1: 1N4148
D2, D3: DIODE
J1: USB-FOO
L1: 68µH
L2: INDUCTOR
P1: OW1_5V
P2: OW1
P3: OW1_GND
P4: OW2_5V
P5: OW2
P6: OW2_GND
P7: 12V+
P8: 12V-
P9: OW3_5V
P10: OW3
P11: OW3_GND
P12: Front+
P13: Back+
P14: Front-
P15: Back-
Q1, Q2: BC817-40; SOT-23
Q3: SOMETHING; SOT-23
R1, R2: 22
R3: 4k7
R4, R5: 0.47
R6, R7, R8, R9, R10, R11: R
R12: 47k
U1: ATMEGA8U2
U3: BTS3134D
U4: MCP6002
X1: 16MHz

Connections:
+5V: C1.1, C6.1, C12.1, P1.1, P4.1, P9.1, U1.4, U1.31, U1.32, U4.8 (VDD); also elsewhere on the board
+12V: C2.1, C7.1, L1.1, P7.1, Q2.3 (C), Q3.3 (D), R3.2; also elsewhere on the board
/FB_Back: C11.1, R11.2, U1.10
/FB_Front: C10.1, R10.2, U1.7
/PWM_Back: R12.1, U1.23
/PWM_Front: U1.25, U3.1 (In)
/back_neg: P15.1, R5.1, U4.5 (+)
/back_pos: C9.1, L2.2, P13.1
/front_neg: P14.1, R4.1, U4.3 (+)
/front_pos: C8.1, D3.2 (K), P12.1
/onewire: P2.1, P5.1, P10.1, U1.22
/xtal1: C3.1, U1.1, X1.1
/xtal2: C5.1, U1.2, X1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D2.1 (A), J1.4, J1.5, J1.6, P3.1, P6.1, P8.1, P11.1, Q1.2 (E), R4.2, R5.2, R6.1, R7.1, U1.3, U1.28, U3.3 (Source), U4.4 (VSS); also elsewhere on the board
unnamed: R9.1, R11.1, U4.7 (Q)
unnamed: D2.2 (K), L2.1, Q3.2 (S)
unnamed: R7.2, R9.2, U4.6 (-)
unnamed: D3.1 (A), L1.2, U3.2 (Drain)
unnamed: C4.1, U1.27
unnamed: R8.1, R10.1, U4.1 (Q)
unnamed: R6.2, R8.2, U4.2 (-)
unnamed: Q1.1 (B), R12.2
unnamed: R1.1, U1.29
unnamed: R2.2, U1.30
unnamed: J1.3, R1.2
unnamed: J1.2, R2.1
unnamed: D1.2 (K), Q1.3 (C), Q2.1 (B), R3.1
unnamed: D1.1 (A), Q2.2 (E), Q3.1 (G)

Notes on the sheet:
Insert LED *here*
Logic power supply
Back light (3W red)
Front light (15W white)

Board: 2 copper layers, 91.4 x 34.3 mm, 53 parts (0 on the bottom side), 28 nets.

Other parts of the board:
U2: LM1117E; SOT223

Their connections:
+5V: U2.2; also elsewhere on the board
+12V: U2.3; also elsewhere on the board
GND: U2.1; also elsewhere on the board

## Commit log

2013-10-15 Initial commit. Basic boost circuit schematic completed.
2013-10-16 Schematic mostly complete
2013-10-18 First draft PCB layout
2013-10-19 Improved ground routing, fixed one error
    The error was a missing VCC connection at the back converter's input
2014-01-11 Added .gitignore and exported gerbers
2014-01-11 Added some info on the back silkscreen

Notices in the files:
converter.kicad_pcb:
CC-BY-SA
Released under Creative Commons
(c) 2014 by jaseg
